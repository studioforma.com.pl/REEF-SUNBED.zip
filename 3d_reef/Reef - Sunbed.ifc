Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Reef - Sunbed.ifc
Time: 2022-03-28T14:37:28
Author: utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (2)
Name
 | Componente#1 - Description: Componente#1; ObjectType: SketchupComponentInstance
 | Componente#2 - Description: Componente#2; ObjectType: SketchupComponentInstance
